# Keil uVision project s3c2440.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: s3c2440
  c flags: Optim=1
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./: S3C2440.s irq.c uart.c uart.h init.c includes.h clock.c main.c
